inherit bundle
RAUC_BUNDLE_COMPATIBLE = "stm32mpu"
RAUC_BUNDLE_SLOTS = "fip bootfs vendorfs rootfs"
RAUC_BUNDLE_FORMAT = "verity"
RAUC_SLOT_bootfs = "st-image-weston"
RAUC_SLOT_bootfs[fstype] = "ext4"
RAUC_SLOT_bootfs[type] = "image"
RAUC_SLOT_bootfs[file] = "st-image-weston-openstlinux-weston-stm32mp1-ota.splitted-bootfs.ext4"
RAUC_SLOT_rootfs = "st-image-weston"
RAUC_SLOT_rootfs[fstype] = "ext4"
RAUC_SLOT_rootfs[type] = "image"
RAUC_SLOT_rootfs[file] = "st-image-weston-openstlinux-weston-stm32mp1-ota.splitted-rootfs.ext4"
RAUC_SLOT_vendorfs = "st-image-weston"
RAUC_SLOT_vendorfs[fstype] = "ext4"
RAUC_SLOT_vendorfs[type] = "image"
RAUC_SLOT_vendorfs[file] = "st-image-weston-openstlinux-weston-stm32mp1-ota.splitted-vendorfs.ext4"
RAUC_SLOT_fip = "fip-stm32mp"
RAUC_SLOT_fip[fstype] = "raw"
RAUC_SLOT_fip[type] = "boot"
RAUC_SLOT_fip[file] = "fip/fip-stm32mp157f-dk2-optee-sdcard.bin"
RAUC_SLOT_fip[rename] = "fip-stm32mp157f-dk2-optee-sdcard.bin"
RAUC_KEY_FILE = "${THISDIR}/files/development-1.key.pem"
RAUC_CERT_FILE = "${THISDIR}/files/development-1.cert.pem"
