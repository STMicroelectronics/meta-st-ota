#
# INSTALL addons for dev images
#
IMAGE_INSTALL:append = "     \
    rauc                     \
    rauc-conf                \
    rauc-service             \
"
